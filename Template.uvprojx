# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\STM32F10x_StdPeriph_Driver\src;.\Public;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\APP\OLED;.\APP\YCKey;.\APP\RTC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c stm32f10x.h stm32f10x_conf.h stm32f10x_it.h
  group Startup
    ./Libraries/CMSIS/: startup_stm32f103xb.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/OLED/: OLED.c
    ./APP/YCKey/: YCKey.c
    ./APP/RTC/: MyRTC.c
  group Public
    ./Public/: system.c SysTick.c usart.c
  group FreeRTOS_CORE
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/include/: FreeRTOSConfig.h
  group FreeRTOS_PORT
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
